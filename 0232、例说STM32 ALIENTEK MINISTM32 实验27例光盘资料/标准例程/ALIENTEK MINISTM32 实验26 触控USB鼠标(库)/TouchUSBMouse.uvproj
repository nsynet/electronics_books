# Keil uVision project TouchUSBMouse.uvproj, settings and files
target FLASH (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TouchUSBMouse +hex
  c flags: Optim=1 OneElfS=1
  c include: .\App;.\LIB\CMSISV1.2.0\Core\CM3;.\LIB\CMSISV1.2.0\Core\CM3\startup\arm;.\LIB\ALIENTEK_MiniSTM32_REVB0_HardWare_V1.1;.\LIB\STM32F10x_StdPeriph_DriverV3.1.1\inc;.\LIB\STM32F10x_StdPeriph_DriverV3.1.1\src;.\LIB\ALIENTEK_MiniSTM32_TFTLCD_REV1.0;.\LIB\STM32_USB-FS-Device_DriverV3.1.1\inc;.\LIB\STM32_USB-FS-Device_DriverV3.1.1\src;.\USB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./LIB/CMSISV1.2.0/Core/CM3/: core_cm3.c system_stm32f10x.c
    ./LIB/CMSISV1.2.0/Core/CM3/startup/arm/: startup_stm32f10x_ld.s
  group APP
    ./App/: main.c stm32f10x_it.c myiic.c touch.c USART.c 24cxx.c
    ./LIB/ALIENTEK_MiniSTM32_REVB0_HardWare_V1.1/: eval.c SysTickDelay.c UART_INTERFACE.c
  group LCD_V1.0
    ./LIB/ALIENTEK_MiniSTM32_TFTLCD_REV1.0/: LCD.c
  group LIB_V3_1_1
    ./LIB/STM32F10x_StdPeriph_DriverV3.1.1/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USB
    ./USB/: hw_config.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c
  group USB-FS-Device_DriverV3.1.1
    ./LIB/STM32_USB-FS-Device_DriverV3.1.1/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
