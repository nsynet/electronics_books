# Keil uVision project Picture.uvproj, settings and files
target FLASH (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Picture +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_LD
  c include: .\App;.\LIB\CMSISV1.2.0\Core\CM3;.\LIB\CMSISV1.2.0\Core\CM3\startup\arm;.\LIB\ALIENTEK_MiniSTM32_REVB0_HardWare_V1.1;.\LIB\STM32F10x_StdPeriph_DriverV3.1.1\src;.\LIB\STM32F10x_StdPeriph_DriverV3.1.1\inc;.\LIB\ALIENTEK_MiniSTM32_TFTLCD_REV1.0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./LIB/CMSISV1.2.0/Core/CM3/: core_cm3.c system_stm32f10x.c
    ./LIB/CMSISV1.2.0/Core/CM3/startup/arm/: startup_stm32f10x_cl.s
  group APP
    ./App/: main.c stm32f10x_it.c FAT.C flash.c fontupd.c jpegdecode.c MMC_SD.C spi.c sysfile.c text.c untogb.c USART.c
    ./LIB/ALIENTEK_MiniSTM32_REVB0_HardWare_V1.1/: eval.c SysTickDelay.c UART_INTERFACE.c
  group LCD_V1.0
    ./LIB/ALIENTEK_MiniSTM32_TFTLCD_REV1.0/: LCD.c
  group LIB_V3_1_1
    ./LIB/STM32F10x_StdPeriph_DriverV3.1.1/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
