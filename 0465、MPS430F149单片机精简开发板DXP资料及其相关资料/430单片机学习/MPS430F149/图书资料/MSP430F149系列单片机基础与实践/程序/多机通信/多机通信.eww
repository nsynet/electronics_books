<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x591A;&#x673A;&#x901A;&#x4Fe1;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


