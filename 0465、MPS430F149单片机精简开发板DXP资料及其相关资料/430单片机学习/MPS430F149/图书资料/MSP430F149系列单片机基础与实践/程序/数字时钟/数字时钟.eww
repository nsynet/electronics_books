<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x6570;&#x5B57;&#x65F6;&#x949F;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


