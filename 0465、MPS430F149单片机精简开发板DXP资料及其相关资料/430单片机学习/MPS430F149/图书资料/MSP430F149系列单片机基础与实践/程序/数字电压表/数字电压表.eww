<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x6570;&#x5B57;&#x7535;&#x538B;&#x8868;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


