<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x4Fe1;&#x53F7;&#x53D1;&#x751F;&#x5668;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


