<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>1</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>4</archiveVersion>
      <data>
        <version>16</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>MacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>MacFile</name>
          <state></state>
        </option>
        <option>
          <name>IProcessor</name>
          <state>0</state>
        </option>
        <option>
          <name>GoToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>GoToName</name>
          <state>main</state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>430FET</state>
        </option>
        <option>
          <name>dDllSlave</name>
          <state>0</state>
        </option>
        <option>
          <name>DdfFileSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>DdfOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>DdfFileName</name>
          <state>$TOOLKIT_DIR$\config\msp430F149.ddf</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIM430</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>SimOddAddressCheckP7</name>
          <state>1</state>
        </option>
        <option>
          <name>CSimMandatory</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>430FET</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CFetMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>PortParallelP7</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>AllCommParallelP7</name>
          <state>1</state>
        </option>
        <option>
          <name>EMUSuppressLoadP7</name>
          <state>0</state>
        </option>
        <option>
          <name>Erase</name>
          <state>1</state>
        </option>
        <option>
          <name>EMUVerifyDownloadP7</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUAskSuppressP7</name>
          <state>0</state>
        </option>
        <option>
          <name>EraseOptionSlaveP7</name>
          <state>0</state>
        </option>
        <option>
          <name>VirtualBreakpointP7</name>
          <state>0</state>
        </option>
        <option>
          <name>ExitBreakpointP7</name>
          <state>0</state>
        </option>
        <option>
          <name>PutcharBreakpointP7</name>
          <state>1</state>
        </option>
        <option>
          <name>GetcharBreakpointP7</name>
          <state>1</state>
        </option>
        <option>
          <name>derivativeP7</name>
          <state>0</state>
        </option>
        <option>
          <name>MarginalReadP7</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\codecoverage.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\profiling.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Trace\trace.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\Lcd\lcd.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\Stack\stack.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>4</archiveVersion>
      <data>
        <version>16</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>MacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>MacFile</name>
          <state></state>
        </option>
        <option>
          <name>IProcessor</name>
          <state>0</state>
        </option>
        <option>
          <name>GoToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>GoToName</name>
          <state>main</state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>SIM430</state>
        </option>
        <option>
          <name>dDllSlave</name>
          <state>0</state>
        </option>
        <option>
          <name>DdfFileSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>DdfOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>DdfFileName</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIM430</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>SimOddAddressCheckP7</name>
          <state>1</state>
        </option>
        <option>
          <name>CSimMandatory</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>430FET</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>CFetMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>PortParallelP7</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>AllCommParallelP7</name>
          <state>1</state>
        </option>
        <option>
          <name>EMUSuppressLoadP7</name>
          <state>0</state>
        </option>
        <option>
          <name>Erase</name>
          <state>1</state>
        </option>
        <option>
          <name>EMUVerifyDownloadP7</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUAskSuppressP7</name>
          <state>0</state>
        </option>
        <option>
          <name>EraseOptionSlaveP7</name>
          <state>0</state>
        </option>
        <option>
          <name>VirtualBreakpointP7</name>
          <state>0</state>
        </option>
        <option>
          <name>ExitBreakpointP7</name>
          <state>0</state>
        </option>
        <option>
          <name>PutcharBreakpointP7</name>
          <state>1</state>
        </option>
        <option>
          <name>GetcharBreakpointP7</name>
          <state>1</state>
        </option>
        <option>
          <name>derivativeP7</name>
          <state>0</state>
        </option>
        <option>
          <name>MarginalReadP7</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\codecoverage.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\profiling.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Trace\trace.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\Lcd\lcd.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\Stack\stack.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
</project>


