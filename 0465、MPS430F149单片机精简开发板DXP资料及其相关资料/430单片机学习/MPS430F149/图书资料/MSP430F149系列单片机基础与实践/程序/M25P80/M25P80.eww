<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\M25P80.ewp</path>
  </project>
  <batchBuild/>
</workspace>


