<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x6A21;&#x62DF;&#x6BD4;&#x8F83;&#x5668;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


