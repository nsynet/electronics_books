<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x6570;&#x7801;&#x7BA1;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


