<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EXFlash\EXFlash.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\EXFlash\EXFlash_A.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SPI\SPI.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SPI\SPI_A.ewp</path>
  </project>
</workspace>


