<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\UART\RS232.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\UART\RS232_A.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\UART\RS485.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\UART\RS485_A.ewp</path>
  </project>
</workspace>


