<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x8D85;&#x4F4e;&#x529F;&#x8017;.ewp</path>
  </project>
</workspace>


