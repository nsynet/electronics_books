<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IIC\IIC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\IIC\IIC_A.ewp</path>
  </project>
</workspace>


