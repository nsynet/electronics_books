<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LCD\LCD.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\LCD\LCD_A.ewp</path>
  </project>
</workspace>


