# IAR project Backup (2) of TimerA.ewp, settings and files
configuration Debug (MSP430, debug)
  XLINK.XclFile: lnk0t.xcl
configuration Release (MSP430)
  as the first configuration, except:
  group (top)
    SourceFile/: TA.c
