# IAR project TimerA.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: MSP430F449 MSP430F449
  General.GStackSize2: 80
  General.GHeapSize2: 80
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430C111 MSP430C111
  group (top)
    SourceFile/: TA.c
