# IAR project Backup of clock.ewp, settings and files
configuration Debug (MSP430, debug)
  ICC430.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: lnk0t.xcl
configuration Release (MSP430)
  as the first configuration, except:
  group (top)
    SourceFile/: clock.c
