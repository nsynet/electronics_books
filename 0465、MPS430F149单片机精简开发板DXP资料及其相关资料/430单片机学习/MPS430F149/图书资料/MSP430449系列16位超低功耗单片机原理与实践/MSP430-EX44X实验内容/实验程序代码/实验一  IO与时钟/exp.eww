<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CLOCK\clock.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\CLOCK\clock_A.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\IO\IO.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\IO\IO_A.ewp</path>
  </project>
</workspace>


