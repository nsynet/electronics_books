# IAR project cc2420_rx.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F449 MSP430F449
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F449.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: MSP430C111 MSP430C111
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: cc2420init.c cc2420run.c main.c
