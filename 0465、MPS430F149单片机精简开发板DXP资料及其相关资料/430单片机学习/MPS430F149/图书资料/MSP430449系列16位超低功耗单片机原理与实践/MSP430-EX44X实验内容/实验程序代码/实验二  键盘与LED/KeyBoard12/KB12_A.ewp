# IAR project KB12_A.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F449 MSP430F449
  General.GStackSize2: 80
  General.GHeapSize2: 80
  A430.AUserIncludes: $TOOLKIT_DIR$\inc\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk430F449.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: MSP430C111 MSP430C111
  XLINK.XclFile: lnk0t.xcl
  group (top)
    SourceFile/: keyboard12.s43
