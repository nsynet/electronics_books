# IAR project Backup (3) of KB12_A.ewp, settings and files
configuration Debug (MSP430, debug)
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk430F449.xcl
configuration Release (MSP430)
  as the first configuration, except:
  XLINK.XclFile: lnk0t.xcl
  group (top)
    SourceFile/: keyboard12.s43
