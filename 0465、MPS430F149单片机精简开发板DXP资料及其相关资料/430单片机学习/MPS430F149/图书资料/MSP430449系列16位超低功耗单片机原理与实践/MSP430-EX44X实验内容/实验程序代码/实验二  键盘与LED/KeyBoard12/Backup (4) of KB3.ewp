# IAR project Backup (4) of KB3.ewp, settings and files
configuration Debug (MSP430, debug)
  ICC430.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk430F449.xcl
configuration Release (MSP430)
  as the first configuration, except:
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../keyBoard3/SourceFile/: main.c
