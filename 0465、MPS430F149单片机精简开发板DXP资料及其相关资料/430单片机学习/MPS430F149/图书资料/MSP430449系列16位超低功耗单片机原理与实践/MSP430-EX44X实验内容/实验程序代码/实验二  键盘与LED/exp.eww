<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\KeyBoard12\KB12.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\KeyBoard12\KB12_A.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\KeyBoard12\KB3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\keyBoard3\KB3_A.ewp</path>
  </project>
</workspace>


