# IAR project KB3.ewp, settings and files
configuration Debug (MSP430, debug)
  XLINK.XclFile: lnk0t.xcl
configuration Release (MSP430)
  as the first configuration, except:
  group (top)
    ../keyBoard3/SourceFile/: main.c
