<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Comparator_A\Cmp_A.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Comparator_A\Cmp_A_A.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Flash\flash.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Flash\flash_a.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Multiplier\mul_A.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Multiplier\multiplier.ewp</path>
  </project>
</workspace>


