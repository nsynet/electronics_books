# IAR project Backup of mul_A.ewp, settings and files
configuration Debug (MSP430, debug)
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk430C111.xcl
configuration Release (MSP430)
  as the first configuration, except:
  XLINK.XclFile: lnk0t.xcl
  group (top)
    Sourcefile/: mul_a.s43
